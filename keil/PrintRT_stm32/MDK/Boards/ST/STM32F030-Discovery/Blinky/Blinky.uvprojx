# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6090000::V6.9::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=3
  c include: ..\..\..\..\..\..\PrintRT_stm32
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ../../../../../: main.cpp Blinky.cpp Thread.hpp
    ./: Thread.cpp spiHandler.cpp
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Inc/: stm32f0xx_it.h
    ./RTE/Device/STM32F030R8Tx/STCubeGenerated/Src/: stm32f0xx_it.c main.c
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.1.1, Compiler:Event Recorder 1.4.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:SPI 2.2, Device:DMA 1.2, Device:GPIO 1.3
